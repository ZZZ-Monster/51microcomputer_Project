# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c AT24C02.c AT24C02.h delay.c delay.h I2C.c I2C.h LCD1602.c LCD1602.h DS18B20.h DS18B20 One Wire.c DS18B20 One Wire.h DS18B20.c Key2.c Key2.h Timer0.c Timer0.h

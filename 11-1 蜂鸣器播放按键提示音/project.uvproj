# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../../89C52 Box/delay延时/: delay.c
    ./: delay.h matrixkey.c matrixkey.h Nixie.c Nixie.h main.c Buzzer.c Buzzer.h

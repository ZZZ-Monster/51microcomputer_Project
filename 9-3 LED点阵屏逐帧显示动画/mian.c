#include <REGX52.H>
#include "delay.H" 
#include "matrixLED.H" 



void main()
{
	MatrixLED_Init();			//初始化
	while(1)
	{	
		unsigned char j,Offset,count;
		unsigned char code TableL[] = {					  //code的内存大，可以放很多，但是code里的数组不能再修改了
		0x5C,0x55,0x77,0x08,0x7F,0x1D,0x2A,0x49,
		0x7F,0x54,0x7F,0x00,0x7F,0x54,0x7F,0x00,
		0x3C,0x42,0xA9,0x85,0x85,0xA9,0x42,0x3C,
		0x3C,0x42,0xA1,0x85,0x85,0xA1,0x42,0x3C,
		0x3C,0x42,0x81,0x81,0x81,0x81,0x42,0x3C,
		0x00,0x00,0x02,0xFF,0x02,0x00,0x00,0x00,}; //逐帧代码
		
		for(j=0;j<8;j++)		  //8列
		{
			MatrixLED_ShowColumn(j,TableL[j+Offset]);
			delay(1);			   //消影操作
			P0=0xff;
		}
		count++;
		if(count>50)	 //count表示代码执行count次之后，左移一位（变相控制了速度）
		{
			count=0;
			Offset+=8;
			if(Offset>45)
				Offset=0;		   //Offset不能一直加，计算好位置清零
		}		
	}
}